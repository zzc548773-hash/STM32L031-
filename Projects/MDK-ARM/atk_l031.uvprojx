# Keil uVision project atk_l031.uvprojx, settings and files
target l031Base (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L031G6Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: atk_l031 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L031xx
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l031xx.s
  group User
    ../../User/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
    ../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c
  group Drivers/BSP
    ../../Drivers/BSP/LOWPOWER/: lowpower_manager.c
    ../../Drivers/BSP/DX_CT511/: dx_ct511.c dx_ct511_uart.c
    ../../Drivers/BSP/EEPROM/: eeprom.c
    ../../Drivers/BSP/IWDG/: iwdg.c
    ../../Drivers/BSP/PWR/: pwr.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/RS485/: rs485.c
  group Readme
    ../../: readme.txt
